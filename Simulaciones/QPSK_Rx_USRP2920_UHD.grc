options:
  parameters:
    author: Grupo A1-GG
    description: Recibe la senal de QPSK_Tx_USRP2920_UHD. AGC, FLL, sincronismo de simbolo (PFB), Costas, decision y deteccion del mensaje.
    generate_options: qt_gui
    id: QPSK_Rx_USRP2920_UHD
    output_language: python
    title: 'QPSK Rx USRP-2920: recepcion del mensaje conocido'
  states: {}

blocks:
- name: Rs
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: cer
  id: variable_function_probe
  parameters:
    block_id: detector_mensaje
    function_name: tasa_error_caracter
    poll_rate: '4'
    value: '0'
  states: {}
- name: clk_bw
  id: variable
  parameters:
    value: 2*math.pi/100
  states: {}
- name: constelacion_qpsk
  id: variable_constellation
  parameters:
    const_points: '[1, 1j, -1, -1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: 2*math.pi/200
  states: {}
- name: decim_rx
  id: variable
  parameters:
    value: int(samp_rate_usrp/math.gcd(int(samp_rate_usrp),int(samp_rate)))
  states: {}
- name: estado_rx
  id: variable_function_probe
  parameters:
    block_id: detector_mensaje
    function_name: estado
    poll_rate: '4'
    value: '"Buscando el mensaje..."'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: fll_bw
  id: variable
  parameters:
    value: 2*math.pi/100
  states: {}
- name: ganancia_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: '"Ganancia Rx [dB]"'
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: interp_rx
  id: variable
  parameters:
    value: int(samp_rate/math.gcd(int(samp_rate_usrp),int(samp_rate)))
  states: {}
- name: lbl_cer
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,0,1,1
    label: '"Tasa de error de caracter"'
    type: real
    value: cer
  states: {}
- name: lbl_estado
  id: variable_qtgui_label
  parameters:
    gui_hint: 4,0,1,2
    label: '"Estado"'
    type: string
    value: estado_rx
  states: {}
- name: lbl_mensaje_rx
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,2
    label: '"Mensaje recibido "'
    type: string
    value: texto_rx
  states: {}
- name: lbl_mensaje_tx
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: '"Mensaje esperado "'
    type: string
    value: mensaje
  states: {}
- name: mensaje
  id: variable
  parameters:
    value: '"UIS - Comunicaciones II - Grupo A1-GG - Enlace QPSK DCI. "'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*Sps, 1.0, beta, span*Sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: samp_rate_usrp
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: texto_rx
  id: variable_function_probe
  parameters:
    block_id: detector_mensaje
    function_name: texto
    poll_rate: '4'
    value: '""'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: adaptacion_tasa
  id: rational_resampler_xxx
  parameters:
    comment: 250 -> 128 kS/s (Sps = 8)
    decim: decim_rx
    fbw: '0.4'
    interp: interp_rx
    taps: ''
    type: ccc
  states: {}
- name: agc
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-1'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: constelacion_rx
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 5,1,4,1
    legend: 'False'
    name: '"Constelacion recuperada"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_bw
  states: {}
- name: decisor_qpsk
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constelacion_qpsk
  states: {}
- name: desvio_freq
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,1,1,1
    label1: '"Hz"'
    max: '10000'
    min: '-10000'
    name: '"Desvio de frecuencia corregido por el FLL [Hz]"'
    type: float
  states: {}
- name: detector_mensaje
  id: epy_block
  parameters:
    _source_code: |
      """
      Detector del mensaje conocido (recepcion con USRP).
      Entrada: indices de simbolo 0..3 decididos con la tabla (1, j, -1, -j).
      El receptor real tiene tres incognitas que el simulador no tenia:
        - ambiguedad de fase de 90 grados del lazo de Costas (indice + k mod 4),
        - en que simbolo empieza cada byte (4 posibilidades),
        - en que caracter del mensaje empieza la ventana.
      Como el mensaje es conocido, se prueban las 16 combinaciones y se elige la que mas
      caracteres acierta; con ella se muestran el texto recibido y la tasa de error de caracter.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, mensaje='UIS - Comunicaciones II - Grupo A1-GG - Enlace QPSK DCI. ', ventanas=2):
              gr.sync_block.__init__(self, name='Detector de mensaje', in_sig=[np.uint8], out_sig=None)
              self.ref = np.frombuffer(mensaje.encode('ascii'), dtype=np.uint8)
              self.L = len(self.ref)
              self.nsym = 4 * self.L * ventanas + 3          # simbolos por ventana de analisis
              self.buf = np.zeros(0, dtype=np.uint8)
              # tabla de referencia con todos los desplazamientos ciclicos del mensaje
              nb = self.L * ventanas
              idx = (np.arange(self.L)[:, None] + np.arange(nb)[None, :]) % self.L
              self.ref_shifts = self.ref[idx]                # (L, nb)
              self.ultimo = ''
              self.rot = 0
              self.n_car = 0
              self.n_err = 0
              self.cer_ventana = 1.0
              self.enganchado = False

          def _bytes(self, s):
              s = s[: (len(s) // 4) * 4].reshape(-1, 4).astype(np.uint16)
              return ((s[:, 0] << 6) | (s[:, 1] << 4) | (s[:, 2] << 2) | s[:, 3]).astype(np.uint8)

          def _analizar(self, s):
              nb = self.ref_shifts.shape[1]
              mejor = (-1, 0, 0, 0, None)
              for rot in range(4):
                  sr = (s.astype(np.int16) - rot) % 4
                  for off in range(4):
                      b = self._bytes(sr[off:off + 4 * nb])
                      aciertos = (self.ref_shifts == b[None, :]).sum(axis=1)
                      k = int(np.argmax(aciertos))
                      if aciertos[k] > mejor[0]:
                          mejor = (int(aciertos[k]), rot, off, k, b)
              acier, rot, off, k, b = mejor
              self.rot = rot
              self.cer_ventana = 1.0 - acier / nb
              # el conteo empieza cuando el receptor se engancha (primera ventana con menos de 25 % de error),
              # para que la adquisicion de la AGC, el FLL y el Costas no infle la tasa de error
              if not self.enganchado and self.cer_ventana < 0.25:
                  self.enganchado = True
              if self.enganchado:
                  self.n_car += nb
                  self.n_err += nb - acier
              ini = (-k) % self.L                            # posicion donde empieza el mensaje
              linea = b[ini:ini + self.L]
              self.ultimo = ''.join(chr(c) if 32 <= c < 127 else '?' for c in linea)

          def work(self, input_items, output_items):
              x = input_items[0]
              self.buf = np.concatenate((self.buf, x))
              while len(self.buf) >= self.nsym:
                  self._analizar(self.buf[:self.nsym])
                  self.buf = self.buf[self.nsym:]
              return len(x)

          def texto(self):
              return self.ultimo

          def tasa_error_caracter(self):
              return self.n_err / self.n_car if self.n_car else 0.0

          def estado(self):
              if not self.enganchado:
                  return 'Buscando el mensaje...'
              return 'Enganchado | ambiguedad de fase corregida: %d grados | error ultima ventana: %.1f %%' % (90 * self.rot, 100 * self.cer_ventana)

          def rotacion(self):
              return 90 * self.rot
    mensaje: mensaje
    ventanas: '2'
  states: {}
- name: espectro_rx
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_usrp
    fc: fc
    fftsize: '1024'
    grid: 'True'
    gui_hint: 5,0,4,1
    legend: 'False'
    name: '"Espectro recibido (centrado en fc)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: beta
    samps_per_sym: Sps
    type: cc
    w: fll_bw
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: nulo_fll
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: rad_a_hz
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*math.pi)
    type: float
  states: {}
- name: rot_mas45
  id: blocks_multiply_const_vxx
  parameters:
    const: cmath.exp(1j*math.pi/4)
    type: complex
  states: {}
- name: rot_menos45
  id: blocks_multiply_const_vxx
  parameters:
    comment: Vuelve a (1, j, -1, -j)
    const: cmath.exp(-1j*math.pi/4)
    type: complex
  states: {}
- name: sincronismo_simbolo
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: clk_bw
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: pfb_taps
    type: ccf
  states: {}
- name: usrp_rx
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    dev_addr: usrp_addr
    dev_args: '""'
    gain0: ganancia_rx
    otw: sc16
    samp_rate: samp_rate_usrp
    sync: none
    type: fc32
  states: {}

connections:
- [adaptacion_tasa, '0', agc, '0']
- [agc, '0', fll, '0']
- [costas, '0', rot_menos45, '0']
- [decisor_qpsk, '0', detector_mensaje, '0']
- [fll, '0', sincronismo_simbolo, '0']
- [fll, '1', rad_a_hz, '0']
- [fll, '2', nulo_fll, '0']
- [fll, '3', nulo_fll, '1']
- [rad_a_hz, '0', desvio_freq, '0']
- [rot_mas45, '0', costas, '0']
- [rot_menos45, '0', constelacion_rx, '0']
- [rot_menos45, '0', decisor_qpsk, '0']
- [sincronismo_simbolo, '0', rot_mas45, '0']
- [usrp_rx, '0', adaptacion_tasa, '0']
- [usrp_rx, '0', espectro_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
