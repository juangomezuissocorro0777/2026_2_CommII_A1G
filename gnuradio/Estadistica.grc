options:
  parameters:
    generate_options: qt_gui
    id: Práctica_1
    output_language: python
    title: Practica 1
  states: {}

blocks:
- name: ruido
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '0.6'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: vector
  id: variable
  parameters:
    value: (1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: ruido
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: vector
  states: {state: disabled}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: vector
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):  # solo argumentos por defecto
              gr.sync_block.__init__(
                  self,
                  name='Averange time',   # Nombre que aparecerá en GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32, np.float32, np.float32, np.float32]
              )
              # Inicialización de acumuladores
              self.acum_anterior = 0.0
              self.acum_anterior1 = 0.0
              self.acum_anterior2 = 0.0
              self.Ntotales = 0

          def work(self, input_items, output_items):
              x = input_items[0]  # Señal de entrada
              y0 = output_items[0]  # Promedio acumulado
              y1 = output_items[1]  # Media (esperanza matemática)
              y2 = output_items[2]  # RMS
              y3 = output_items[3]  # Potencia promedio
              y4 = output_items[4]  # Desviación estándar
              # Número de muestras en este bloque
       

              # --- Cálculo del promedio ---
         
              y0[:] = np.mean(x)

              # --- Cálculo de la media cuadrática (para RMS) ---

              media_cuadratica = np.mean(x**2)

              # --- RMS ---
              y2[:] = np.sqrt(media_cuadratica)

              # --- Potencia promedio ---
              y3[:] = media_cuadratica

              # --- Media (simplemente el promedio) ---
              y1[:] = media_cuadratica

              # --- Desviación estándar ---

              y4[:] = np.std(x)

              return len(x)
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Differenciator',   # aparecerá en GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.last_sample = 0.0   # última muestra del bloque anterior

          def work(self, input_items, output_items):
              x = input_items[0]   # señal de entrada
              y0 = output_items[0] # señal de salida (diferenciada)

              # Calcular diferencias
              y0[0] = x[0] - self.last_sample   # primera diferencia usando la memoria
              y0[1:] = np.diff(x)               # diferencias dentro del bloque

              # Guardar la última muestra del bloque actual
              self.last_sample = x[-1]

              return len(y0)
  states: {state: disabled}
- name: qtgui_number_sink_0_3_0_0
  id: qtgui_number_sink
  parameters:
    color2: ("blue", "red")
    color3: ("black", "white")
    color4: ("white", "black")
    color5: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Media
    label2: Media Cuadrárica
    label3: RMS
    label4: Promedio Tiempo
    label5: Desviación Estándar
    name: Estadistica_señal
    nconnections: '5'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Salida
    name: '"Salida"'
    size: '300'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Entrada
    name: '"Entrada"'
    size: '300'
    srate: samp_rate/4
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Entrada
    name: Señal de entrada
    size: '100'
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_head_0, '0']
- [blocks_add_xx_0, '0', epy_block_0_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0_0, '0', epy_block_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_head_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_add_xx_0_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0_3_0_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_3_0_0, '1']
- [epy_block_0, '2', qtgui_number_sink_0_3_0_0, '2']
- [epy_block_0, '3', qtgui_number_sink_0_3_0_0, '3']
- [epy_block_0, '4', qtgui_number_sink_0_3_0_0, '4']
- [epy_block_0_0_0_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
