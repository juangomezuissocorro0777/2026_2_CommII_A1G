options:
  parameters:
    author: A1G
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Practica_1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      cosa:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, 

          def __init__(self):  # only default arguments here
      	gr. sync_block . __init__ (
      		self ,
      		name =’e_Diff ’, # will show up in GRC
      		in_sig =[ np. float32 ],
      		out_sig =[ np. float32 ]
      	self . acum_anterior = 0
      	)

          def work (self , input_items , output_items ):
      	x = input_items [0] # Senial de entrada .
      	y0 = output_items [0] # Senial acumulada diferencial
      	N = len (x)
      	diff = np. cumsum (x) - self . acum_anterior
      	self . acum_anterior = diff [N -1]
      	y0 [:] = diff
      	return len (y)
    alias: kkkk
    example_param: '1.0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
